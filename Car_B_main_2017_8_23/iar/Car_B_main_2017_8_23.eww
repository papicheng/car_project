<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Car_B_main_2017_8_23_K60DZ10.ewp</path>
  </project>
  <batchBuild></batchBuild>
</workspace>